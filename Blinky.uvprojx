# Keil uVision project Blinky.uvprojx, settings and files
target LPC1768 Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: --diag_suppress 550
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    ./: system_LPC17xx.c
  group Core Code
    ./: core_cm3.c
  group Source Code
    ./: adcuser.c game.c GLCD_SPI_LPC1700.c IRQ.c KBD.c LED.c Main.c Menu.c nowpanic.c PhotoLib.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c drawing.c pong.c Collector.c
    ../../project 2/MediaCenter/Boards/Keil/MCB1700/Blinky_ULp/: babymeme.c BronBron.c COLEPALMER.c ColeStare.c
  group Pictures
    ./: star.c MediaCenterV1.c iraq.c leftMenu.c userGenerated.c MediaCenterHeader.c HEADINGG.c
  group Documentation
    ./: Abstract.txt
  group Custom Headers
    ./: Menu.h PhotoLib.h LPC17xx.h type.h adcuser.h usbdmain.h game.h usb.h usbaudio.h usbcfg.h usbcore.h usbdesc.h usbhw.h usbreg.h usbuser.h Pong.h
software components: CMSIS:CORE 5.4.0
